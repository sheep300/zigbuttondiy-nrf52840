## archive/D5/Kconfig
```kconfig
mainmenu "ZigButton controlled diagnostics"
source "Kconfig.zephyr"
config DIAG_ZIGBEE
    bool "Enable Zigbee diagnostic D"
    default n
```
